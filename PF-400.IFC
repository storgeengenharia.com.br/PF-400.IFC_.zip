Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: PF-400.IFC
Time: 2024-08-29T11:37:28
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Chapa Ventilador
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: IR 400BK ST
In: Default Storey
Material: Liga de aço (SS)

# IfcBuildingElementProxy: Suporte do Motor
In: Default Storey
Material: Aço galvanizado
